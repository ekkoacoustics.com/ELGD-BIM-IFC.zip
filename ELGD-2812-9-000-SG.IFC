Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2812-9-000-SG.IFC
Time: 2024-11-05T12:31:47+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 29.5272971603026910; Volume Measure: 0.0295272971603027; Area Measure: 6.9871019132065539

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 29.5272971603026910; Volume Measure: 0.0295272971603027; Area Measure: 6.9871019132065539

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 29.5272971603026910; Volume Measure: 0.0295272971603027; Area Measure: 6.9871019132065539

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2812-9-000-SG | PSet_Mass_Property - Mass Measure: 29.5272971603026910; Volume Measure: 0.0295272971603027; Area Measure: 6.9871019132065539
ELGD-2812-9-000-SG | SOLIDWORKS Custom Properties - PartNo: ELGD-2812-9-000-SG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2

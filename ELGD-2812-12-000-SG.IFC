Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2812-12-000-SG.IFC
Time: 2024-11-05T12:31:15+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 39.6072971603036237; Volume Measure: 0.0396072971603036; Area Measure: 7.0111019132065451

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 39.6072971603036237; Volume Measure: 0.0396072971603036; Area Measure: 7.0111019132065451

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 39.6072971603036237; Volume Measure: 0.0396072971603036; Area Measure: 7.0111019132065451

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2812-12-000-SG | PSet_Mass_Property - Mass Measure: 39.6072971603036237; Volume Measure: 0.0396072971603036; Area Measure: 7.0111019132065451
ELGD-2812-12-000-SG | SOLIDWORKS Custom Properties - PartNo: ELGD-2812-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2

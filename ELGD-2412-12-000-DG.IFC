Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2412-12-000-DG.IFC
Time: 2024-11-05T12:32:31+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 31.5663640204843645; Volume Measure: 0.0315663640204844; Area Measure: 6.1932025340938468

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 31.5663640204843645; Volume Measure: 0.0315663640204844; Area Measure: 6.1932025340938468

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 31.5663640204843645; Volume Measure: 0.0315663640204844; Area Measure: 6.1932025340938468

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2412-12-000-DG | PSet_Mass_Property - Mass Measure: 31.5663640204843645; Volume Measure: 0.0315663640204844; Area Measure: 6.1932025340938468
ELGD-2412-12-000-DG | SOLIDWORKS Custom Properties - PartNo: ELGD-2412-12-000-DG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2

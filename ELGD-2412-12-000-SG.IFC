Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2412-12-000-SG.IFC
Time: 2024-11-05T12:32:17+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 33.9491114209431473; Volume Measure: 0.0339491114209431; Area Measure: 6.0135666605053846

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 33.9491114209431473; Volume Measure: 0.0339491114209431; Area Measure: 6.0135666605053846

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 33.9491114209431473; Volume Measure: 0.0339491114209431; Area Measure: 6.0135666605053846

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2412-12-000-SG | PSet_Mass_Property - Mass Measure: 33.9491114209431473; Volume Measure: 0.0339491114209431; Area Measure: 6.0135666605053846
ELGD-2412-12-000-SG | SOLIDWORKS Custom Properties - PartNo: ELGD-2412-12-000-SG; Revision: A; Material: 12MM EKKO ACOUSTIC PANEL; Finish: 6MM WIDE X 3MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2

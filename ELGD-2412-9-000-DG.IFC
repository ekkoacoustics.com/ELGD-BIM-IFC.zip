Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2412-9-000-DG.IFC
Time: 2024-11-05T12:33:02+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 22.9263640204840371; Volume Measure: 0.0229263640204840; Area Measure: 6.1716025340938447

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 22.9263640204840371; Volume Measure: 0.0229263640204840; Area Measure: 6.1716025340938447

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 22.9263640204840371; Volume Measure: 0.0229263640204840; Area Measure: 6.1716025340938447

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2412-9-000-DG | PSet_Mass_Property - Mass Measure: 22.9263640204840371; Volume Measure: 0.0229263640204840; Area Measure: 6.1716025340938447
ELGD-2412-9-000-DG | SOLIDWORKS Custom Properties - PartNo: ELGD-2412-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2

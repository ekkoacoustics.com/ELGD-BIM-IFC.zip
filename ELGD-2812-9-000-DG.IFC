Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Lines_Diagonal\ELGD-2812-9-000-DG.IFC
Time: 2024-11-05T12:32:04+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 26.7474246905651505; Volume Measure: 0.0267474246905651; Area Measure: 7.1970187621108916

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 26.7474246905651505; Volume Measure: 0.0267474246905651; Area Measure: 7.1970187621108916

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 26.7474246905651505; Volume Measure: 0.0267474246905651; Area Measure: 7.1970187621108916

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
ELGD-2812-9-000-DG | PSet_Mass_Property - Mass Measure: 26.7474246905651505; Volume Measure: 0.0267474246905651; Area Measure: 7.1970187621108916
ELGD-2812-9-000-DG | SOLIDWORKS Custom Properties - PartNo: ELGD-2812-9-000-DG; Revision: A; Material: 9MM EKKO ACOUSTIC PANEL; Finish: 14MM WIDE X 7MM DEEP V-GROOVE; CheckedBy: DG; DrawnBy: CAM; Client: EKKO; Description: LINES_DIAGONAL; Project: EKKO PRODUCT LIST; sets with these values: 2
